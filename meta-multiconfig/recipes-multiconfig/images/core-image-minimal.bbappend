#
do_image[mcdepends] = " multiconfig:host:container:container-image-minimal:do_image"

IMAGE_INSTALL_append = " container-multiconfig"
